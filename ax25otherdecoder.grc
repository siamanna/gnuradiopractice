options:
  parameters:
    author: sia
    generate_options: qt_gui
    id: ax25otherdecoder
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /Users/sia/Downloads/test.txt
    repeat: 'True'
    type: float
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_descrambler_bb_0
  id: digital_descrambler_bb
  parameters:
    len: '7'
    mask: '0x8A'
    seed: '0x7F'
  states: {}
- name: digital_hdlc_deframer_bp_0
  id: digital_hdlc_deframer_bp
  parameters:
    max: '500'
    min: '32'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: satellites_check_address_1
  id: satellites_check_address
  parameters:
    address: 0000CQ
    direction: '"from"'
  states: {}
- name: satellites_fsk_demodulator_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: '9600'
    samp_rate: samp_rate
    subaudio: 'False'
  states: {}
- name: satellites_nrzi_decode_0
  id: satellites_nrzi_decode
  parameters: {}
  states: {}

connections:
- [blocks_file_source_0, '0', qtgui_sink_x_0, '0']
- [blocks_file_source_0, '0', satellites_fsk_demodulator_0, '0']
- [digital_binary_slicer_fb_0, '0', satellites_nrzi_decode_0, '0']
- [digital_descrambler_bb_0, '0', digital_hdlc_deframer_bp_0, '0']
- [digital_hdlc_deframer_bp_0, out, satellites_check_address_1, in]
- [satellites_check_address_1, ok, blocks_file_sink_0, '0']
- [satellites_check_address_1, ok, blocks_message_debug_0, print_pdu]
- [satellites_fsk_demodulator_0, '0', digital_binary_slicer_fb_0, '0']
- [satellites_nrzi_decode_0, '0', digital_descrambler_bb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
